# Keil uVision project _L476_JoyItCar_leds_sw.uvprojx, settings and files
target _L476_JoyItCar_leds_sw (6220000::V6.22::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.3.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: _L476_JoyItCar_leds_sw
  AfterMake: $K\ARM\ARMCLANG\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 v6LangP=7
  c define: TARGET_FF_ARDUINO_UNO USE_FULL_LL_DRIVER MBED_BUILD_TIMESTAMP=1748017191.963155 DEVICE_INTERRUPTIN=1 TOOLCHAIN_ARMC6 __CMSIS_RTOS DEVICE_I2C_ASYNCH=1 USE_HAL_DRIVER DEVICE_MPU=1 DEVICE_SLEEP=1 TOOLCHAIN_ARM TARGET_CORTEX TARGET_CORTEX_M DEVICE_SPI_ASYNCH=1 TARGET_STM MBED_RAM_START=0x20000000 DEVICE_ANALOGIN=1 TARGET_MCU_STM32L4 MBED_SPLIT_HEAP DEVICE_WATCHDOG=1 TARGET_STM32L476xG DEVICE_PORTOUT=1 TARGET_LIKE_CORTEX_M4 TARGET_NAME=NUCLEO_L476RG TARGET_RELEASE DEVICE_SERIAL=1 __MBED__=1 DEVICE_FLASH=1 TOOLCHAIN_ARM_STD TARGET_RTOS_M4_M7 TRANSACTION_QUEUE_SIZE_SPI=2 DEVICE_SERIAL_ASYNCH=1 TARGET_M4 TARGET_STM32L4 MULADDC_CANNOT_USE_R7 EXTRA_IDLE_STACK_REQUIRED MBED_TICKLESS DEVICE_PORTINOUT=1 DEVICE_RESET_REASON=1 MBED_MINIMAL_PRINTF MBED_DEBUG TARGET_LIKE_MBED __MICROLIB TARGET_MCU_STM32L476xG __CORTEX_M4 MBED_RTOS_SINGLE_THREAD DEVICE_I2CSLAVE=1 MBED_RAM1_SIZE=0x8000 MBED_RAM1_START=0x10000000 DEVICE_LPTICKER=1 DEVICE_SPI=1 TARGET_MCU_STM32 TARGET_NUCLEO_L476RG DEVICE_I2C=1 MBED_TRAP_ERRORS_ENABLED=1 ARM_MATH_CM4 DEVICE_PWMOUT=1 DEVICE_SPISLAVE=1 DEVICE_RTC=1 DEVICE_ANALOGOUT=1 DEVICE_CAN=1 __FPU_PRESENT=1 DEVICE_TRNG=1 COMPONENT_FLASHIAP=1 MBED_ROM_SIZE=0x100000 MBED_RAM_SIZE=0x18000 DEVICE_SERIAL_FC=1 DEVICE_CRC=1 DEVICE_STDIO_MESSAGES=1 DEVICE_USTICKER=1 MBED_ROM_START=0x8000000 STM32L476xx __MBED_CMSIS_RTOS_CM __ASSERT_MSG DEVICE_PORTIN=1
  c misc: -fno-rtti -Wno-armcc-pragma-push-pop -fshort-wchar -mfpu=fpv4-sp-d16 -g -Wno-deprecated-register --target=arm-arm-none-eabi -fdata-sections -Wno-armcc-pragma-anon-unions -fno-exceptions -fno-c++-static-destructors -mthumb -mfloat-abi=hard -mcpu=cortex-m4 -c -fshort-enums -Wno-reserved-user-defined-literal -include mbed_config.h
  c include: .;C:/Keil_v5/mbed-os;C:/Keil_v5/mbed-os/cmsis;C:/Keil_v5/mbed-os/cmsis/CMSIS_5;C:/Keil_v5/mbed-os/cmsis/CMSIS_5/CMSIS;C:/Keil_v5/mbed-os/cmsis/CMSIS_5/CMSIS/RTOS2;C:/Keil_v5/mbed-os/cmsis/CMSIS_5/CMSIS/TARGET_CORTEX_M;C:/Keil_v5/mbed-os/cmsis/CMSIS_5/CMSIS/TARGET_CORTEX_M/Include;C:/Keil_v5/mbed-os/cmsis/device;C:/Keil_v5/mbed-os/cmsis/device/RTE;C:/Keil_v5/mbed-os/cmsis/device/RTE/include;C:/Keil_v5/mbed-os/cmsis/device/rtos;C:/Keil_v5/mbed-os/connectivity;C:/Keil_v5/mbed-os/connectivity/cellular;C:/Keil_v5/mbed-os/connectivity/drivers;C:/Keil_v5/mbed-os/connectivity/drivers/802.15.4_RF;C:/Keil_v5/mbed-os/connectivity/drivers/802.15.4_RF/atmel-rf-driver;C:/Keil_v5/mbed-os/connectivity/drivers/802.15.4_RF/mcr20a-rf-driver;C:/Keil_v5/mbed-os/connectivity/drivers/802.15.4_RF/stm-s2lp-rf-driver;C:/Keil_v5/mbed-os/connectivity/drivers/cellular;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/Altair;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/Altair/ALT1250;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/Altair/ALT1250/PPP;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/GEMALTO;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/GEMALTO/CINTERION;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/GENERIC;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/GENERIC/GENERIC_AT3GPP;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/MultiTech;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/MultiTech/DragonflyNano;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/MultiTech/DragonflyNano/PPP;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/QUECTEL;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/QUECTEL/BC95;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/QUECTEL/BG96;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/QUECTEL/EC2X;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/QUECTEL/M26;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/QUECTEL/UG96;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/RiotMicro;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/RiotMicro/AT;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/TELIT;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/TELIT/HE910;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/TELIT/ME310;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/TELIT/ME910;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/UBLOX;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/UBLOX/AT;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/UBLOX/N2XX;C:/Keil_v5/mbed-os/connectivity/drivers/cellular/UBLOX/PPP;C:/Keil_v5/mbed-os/connectivity/drivers/emac/TARGET_STM;C:/Keil_v5/mbed-os/connectivity/drivers/mbedtls/TARGET_STM;C:/Keil_v5/mbed-os/connectivity/drivers/nfc;C:/Keil_v5/mbed-os/connectivity/drivers/nfc/PN512;C:/Keil_v5/mbed-os/connectivity/drivers/wifi;C:/Keil_v5/mbed-os/connectivity/drivers/wifi/esp8266-driver;C:/Keil_v5/mbed-os/connectivity/libraries;C:/Keil_v5/mbed-os/connectivity/libraries/mbed-coap;C:/Keil_v5/mbed-os/connectivity/libraries/nanostack-libservice;C:/Keil_v5/mbed-os/connectivity/libraries/ppp;C:/Keil_v5/mbed-os/connectivity/lorawan;C:/Keil_v5/mbed-os/connectivity/lwipstack;C:/Keil_v5/mbed-os/connectivity/mbedtls;C:/Keil_v5/mbed-os/connectivity/nanostack;C:/Keil_v5/mbed-os/connectivity/netsocket;C:/Keil_v5/mbed-os/connectivity/nfc;C:/Keil_v5/mbed-os/drivers;C:/Keil_v5/mbed-os/drivers/device_key;C:/Keil_v5/mbed-os/drivers/include;C:/Keil_v5/mbed-os/drivers/include/drivers;C:/Keil_v5/mbed-os/drivers/include/drivers/interfaces;C:/Keil_v5/mbed-os/drivers/usb;C:/Keil_v5/mbed-os/events;C:/Keil_v5/mbed-os/features;C:/Keil_v5/mbed-os/features/frameworks;C:/Keil_v5/mbed-os/features/frameworks/greentea-client;C:/Keil_v5/mbed-os/features/frameworks/mbed-client-cli;C:/Keil_v5/mbed-os/features/frameworks/unity;C:/Keil_v5/mbed-os/features/frameworks/utest;C:/Keil_v5/mbed-os/hal;C:/Keil_v5/mbed-os/hal/include;C:/Keil_v5/mbed-os/hal/include/hal;C:/Keil_v5/mbed-os/hal/usb;C:/Keil_v5/mbed-os/hal/usb/include;C:/Keil_v5/mbed-os/hal/usb/include/usb;C:/Keil_v5/mbed-os/platform;C:/Keil_v5/mbed-os/platform/cxxsupport;C:/Keil_v5/mbed-os/platform/include;C:/Keil_v5/mbed-os/platform/include/platform;C:/Keil_v5/mbed-os/platform/include/platform/internal;C:/Keil_v5/mbed-os/platform/mbed-trace;C:/Keil_v5/mbed-os/platform/mbed-trace/include;C:/Keil_v5/mbed-os/platform/mbed-trace/include/mbed-trace;C:/Keil_v5/mbed-os/platform/randlib;C:/Keil_v5/mbed-os/platform/source;C:/Keil_v5/mbed-os/platform/source/minimal-printf;C:/Keil_v5/mbed-os/rtos;C:/Keil_v5/mbed-os/rtos/include;C:/Keil_v5/mbed-os/rtos/include/rtos;C:/Keil_v5/mbed-os/rtos/include/rtos/internal;C:/Keil_v5/mbed-os/rtos/source;C:/Keil_v5/mbed-os/storage;C:/Keil_v5/mbed-os/storage/blockdevice;C:/Keil_v5/mbed-os/storage/blockdevice/COMPONENT_FLASHIAP;C:/Keil_v5/mbed-os/storage/blockdevice/include;C:/Keil_v5/mbed-os/storage/blockdevice/include/blockdevice;C:/Keil_v5/mbed-os/storage/blockdevice/include/blockdevice/internal;C:/Keil_v5/mbed-os/storage/filesystem;C:/Keil_v5/mbed-os/storage/kvstore;C:/Keil_v5/mbed-os/targets/TARGET_STM;C:/Keil_v5/mbed-os/targets/TARGET_STM/TARGET_STM32L4;C:/Keil_v5/mbed-os/targets/TARGET_STM/TARGET_STM32L4/STM32Cube_FW;C:/Keil_v5/mbed-os/targets/TARGET_STM/TARGET_STM32L4/STM32Cube_FW/CMSIS;C:/Keil_v5/mbed-os/targets/TARGET_STM/TARGET_STM32L4/STM32Cube_FW/STM32L4xx_HAL_Driver;C:/Keil_v5/mbed-os/targets/TARGET_STM/TARGET_STM32L4/STM32Cube_FW/STM32L4xx_HAL_Driver/Legacy;C:/Keil_v5/mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L476xG;C:/Keil_v5/mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L476xG/TARGET_NUCLEO_L476RG;D:/tools/git_repo/digital_methods/keil_stm32/MBED_os/boards/L476RG/_L476_JoyItCar_leds_sw/mbed-os;D:\tools\git_repo\digital_methods\keil_stm32\MBED_os\boards\L476RG\_L476_JoyItCar_leds_sw\libs
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__MBED_CMSIS_RTOS_CM,-DUSE_FULL_LL_DRIVER,-DMBED_SPLIT_HEAP,-DEXTRA_IDLE_STACK_REQUIRED,-DMBED_TICKLESS,-DUSE_HAL_DRIVER,-D__FPU_PRESENT=1,-DTRANSACTION_QUEUE_SIZE_SPI=2,-DSTM32L476xx,-DARM_MATH_CM4,-D__CMSIS_RTOS,-D__CORTEX_M4
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: C:/Keil_v5/mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L476xG/TOOLCHAIN_ARM/stm32l476xg.sct
  link misc: --predefine="-DMBED_RAM_START=0x20000000" --predefine="-DMBED_RAM_SIZE=0x18000" --library_type=microlib --any_contingency --verbose --keep=os_cb_sections --predefine="-DXIP_ENABLE=0" --predefine="-DMBED_RAM1_START=0x10000000" --predefine="-DMBED_BOOT_STACK_SIZE=4096" --show_full_path --cpu=Cortex-M4 --predefine="-DMBED_RAM1_SIZE=0x8000" --remove --predefine="-DMBED_ROM_SIZE=0x100000" --predefine="-DMBED_ROM_START=0x8000000"
  group mbed-os
    C:/Keil_v5/mbed-os/drivers/include/drivers/: AnalogIn.h AnalogOut.h BufferedSerial.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h FlashIAP.h HighResClock.h I2C.h I2CSlave.h InterruptIn.h LowPowerClock.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h MbedCRC.h OSPI.h PortIn.h PortInOut.h PortOut.h PwmOut.h QSPI.h RawCAN.h RealTimeClock.h ResetReason.h SerialBase.h SerialWireOutput.h SPI.h SPISlave.h Ticker.h TickerDataClock.h Timeout.h Timer.h TimerEvent.h UnbufferedSerial.h Watchdog.h
    C:/Keil_v5/mbed-os/hal/include/hal/: analogin_api.h analogout_api.h buffer.h can_helper.h crc_api.h critical_section_api.h dma_api.h flash_api.h gpio_api.h gpio_irq_api.h i2c_api.h itm_api.h LowPowerTickerWrapper.h lp_ticker_api.h mbed_lp_ticker_wrapper.h mpu_api.h ospi_api.h pinmap.h PinNameAliases.h port_api.h pwmout_api.h qspi_api.h reset_reason_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h static_pinmap.h ticker_api.h trng_api.h us_ticker_api.h watchdog_api.h can_api.h
    C:/Keil_v5/mbed-os/platform/include/platform/: ATCmdParser.h Callback.h CircularBuffer.h CriticalSectionLock.h CThunk.h DeepSleepLock.h DirHandle.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemHandle.h FileSystemLike.h LocalFileSystem.h mbed_application.h mbed_assert.h mbed_atomic.h mbed_chrono.h mbed_critical.h mbed_debug.h mbed_enum_flags.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_mktime.h mbed_mpu_mgmt.h mbed_poll.h mbed_power_mgmt.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_stats.h mbed_thread.h mbed_toolchain.h mbed_version.h mbed_wait_api.h NonCopyable.h platform.h PlatformMutex.h ScopedLock.h ScopedRamExecutionLock.h ScopedRomWriteLock.h SharedPtr.h SingletonPtr.h Span.h Stream.h Transaction.h
    C:/Keil_v5/mbed-os/storage/blockdevice/include/blockdevice/: BlockDevice.h BufferedBlockDevice.h ChainingBlockDevice.h ExhaustibleBlockDevice.h FlashSimBlockDevice.h HeapBlockDevice.h MBRBlockDevice.h ObservingBlockDevice.h ProfilingBlockDevice.h ReadOnlyBlockDevice.h SlicingBlockDevice.h
    C:/Keil_v5/mbed-os/cmsis/CMSIS_5/CMSIS/TARGET_CORTEX_M/Include/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h pmu_armv8.h tz_context.h
    C:/Keil_v5/mbed-os/targets/TARGET_STM/TARGET_STM32L4/: can_device.h cmsis.h gpio_irq_device.h i2c_device.h objects.h PeripheralNames.h pin_device.h pwmout_device.h spi_device.h us_ticker_data.h
    C:/Keil_v5/mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L476xG/: cmsis_nvic.h
    C:/Keil_v5/mbed-os/rtos/include/rtos/: ConditionVariable.h EventFlags.h Kernel.h Mail.h mbed_rtos_types.h MemoryPool.h Mutex.h Queue.h rtos.h Semaphore.h ThisThread.h Thread.h
    C:/Keil_v5/mbed-os/platform/include/platform/internal/: CThunkBase.h mbed_atomic_impl.h mbed_error_hist.h mbed_fault_handler.h mbed_os_timer.h SysTimer.h
    C:/Keil_v5/mbed-os/targets/TARGET_STM/: device.h gpio_object.h lp_ticker_defines.h mbed_rtx.h nvic_addr.h PeripheralPins.h PinNamesTypes.h PortNames.h rtc_api_hal.h serial_api_hal.h stm32_assert.h us_ticker_defines.h USBPhyHw.h
    C:/Keil_v5/mbed-os/drivers/include/drivers/interfaces/: InterfaceCAN.h InterfaceDigitalIn.h InterfaceDigitalInOut.h InterfaceDigitalOut.h
    C:/Keil_v5/mbed-os/: mbed.h
    C:/Keil_v5/mbed-os/cmsis/device/: mbed_cmsis_conf.h
    C:/Keil_v5/mbed-os/platform/source/: mbed_crash_data_offsets.h
    C:/Keil_v5/mbed-os/platform/source/minimal-printf/: mbed_printf_implementation.h
    C:/Keil_v5/mbed-os/rtos/include/rtos/internal/: mbed_rtos1_types.h mbed_rtos_storage.h
    C:/Keil_v5/mbed-os/platform/mbed-trace/include/mbed-trace/: mbed_trace.h ns_trace.h
    C:/Keil_v5/mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L476xG/TARGET_NUCLEO_L476RG/: PinNames.h
    C:/Keil_v5/mbed-os/cmsis/device/RTE/include/: RTE_Components.h
    C:/Keil_v5/mbed-os/rtos/source/: rtos_handlers.h rtos_idle.h
    C:/Keil_v5/mbed-os/storage/blockdevice/include/blockdevice/internal/: SFDP.h
    C:/Keil_v5/mbed-os/targets/TARGET_STM/TARGET_STM32L4/STM32Cube_FW/STM32L4xx_HAL_Driver/Legacy/: stm32_hal_legacy.h stm32l4xx_hal_can_legacy.h
    C:/Keil_v5/mbed-os/targets/TARGET_STM/TARGET_STM32L4/STM32Cube_FW/CMSIS/: stm32l412xx.h stm32l422xx.h stm32l431xx.h stm32l432xx.h stm32l433xx.h stm32l442xx.h stm32l443xx.h stm32l451xx.h stm32l452xx.h stm32l462xx.h stm32l471xx.h stm32l475xx.h stm32l476xx.h stm32l485xx.h stm32l486xx.h stm32l496xx.h stm32l4a6xx.h stm32l4p5xx.h stm32l4q5xx.h stm32l4r5xx.h stm32l4r7xx.h stm32l4r9xx.h stm32l4s5xx.h stm32l4s7xx.h stm32l4s9xx.h stm32l4xx.h system_stm32l4xx.h
    C:/Keil_v5/mbed-os/targets/TARGET_STM/TARGET_STM32L4/STM32Cube_FW/STM32L4xx_HAL_Driver/: stm32l4xx_hal.h stm32l4xx_hal_adc.h stm32l4xx_hal_adc_ex.h stm32l4xx_hal_can.h stm32l4xx_hal_comp.h stm32l4xx_hal_cortex.h stm32l4xx_hal_crc.h stm32l4xx_hal_crc_ex.h stm32l4xx_hal_cryp.h stm32l4xx_hal_cryp_ex.h stm32l4xx_hal_dac.h stm32l4xx_hal_dac_ex.h stm32l4xx_hal_dcmi.h stm32l4xx_hal_def.h stm32l4xx_hal_dfsdm.h stm32l4xx_hal_dfsdm_ex.h stm32l4xx_hal_dma.h stm32l4xx_hal_dma2d.h stm32l4xx_hal_dma_ex.h stm32l4xx_hal_dsi.h stm32l4xx_hal_exti.h stm32l4xx_hal_firewall.h stm32l4xx_hal_flash.h stm32l4xx_hal_flash_ex.h stm32l4xx_hal_flash_ramfunc.h stm32l4xx_hal_gfxmmu.h stm32l4xx_hal_gpio.h stm32l4xx_hal_gpio_ex.h stm32l4xx_hal_hash.h stm32l4xx_hal_hash_ex.h stm32l4xx_hal_hcd.h stm32l4xx_hal_i2c.h stm32l4xx_hal_i2c_ex.h stm32l4xx_hal_irda.h stm32l4xx_hal_irda_ex.h stm32l4xx_hal_iwdg.h stm32l4xx_hal_lcd.h stm32l4xx_hal_lptim.h stm32l4xx_hal_ltdc.h stm32l4xx_hal_ltdc_ex.h stm32l4xx_hal_mmc.h stm32l4xx_hal_mmc_ex.h stm32l4xx_hal_nand.h stm32l4xx_hal_nor.h stm32l4xx_hal_opamp.h stm32l4xx_hal_opamp_ex.h stm32l4xx_hal_ospi.h stm32l4xx_hal_pcd.h stm32l4xx_hal_pcd_ex.h stm32l4xx_hal_pka.h stm32l4xx_hal_pssi.h stm32l4xx_hal_pwr.h stm32l4xx_hal_pwr_ex.h stm32l4xx_hal_qspi.h stm32l4xx_hal_rcc.h stm32l4xx_hal_rcc_ex.h stm32l4xx_hal_rng.h stm32l4xx_hal_rng_ex.h stm32l4xx_hal_rtc.h stm32l4xx_hal_rtc_ex.h stm32l4xx_hal_sai.h stm32l4xx_hal_sai_ex.h stm32l4xx_hal_sd.h stm32l4xx_hal_sd_ex.h stm32l4xx_hal_smartcard.h stm32l4xx_hal_smartcard_ex.h stm32l4xx_hal_smbus.h stm32l4xx_hal_smbus_ex.h stm32l4xx_hal_spi.h stm32l4xx_hal_spi_ex.h stm32l4xx_hal_sram.h stm32l4xx_hal_swpmi.h stm32l4xx_hal_tim.h stm32l4xx_hal_tim_ex.h stm32l4xx_hal_tsc.h stm32l4xx_hal_uart.h stm32l4xx_hal_uart_ex.h stm32l4xx_hal_usart.h stm32l4xx_hal_usart_ex.h stm32l4xx_hal_wwdg.h stm32l4xx_ll_adc.h stm32l4xx_ll_bus.h stm32l4xx_ll_comp.h stm32l4xx_ll_cortex.h stm32l4xx_ll_crc.h stm32l4xx_ll_crs.h stm32l4xx_ll_dac.h stm32l4xx_ll_dma.h stm32l4xx_ll_dma2d.h stm32l4xx_ll_dmamux.h stm32l4xx_ll_exti.h stm32l4xx_ll_fmc.h stm32l4xx_ll_gpio.h stm32l4xx_ll_i2c.h stm32l4xx_ll_iwdg.h stm32l4xx_ll_lptim.h stm32l4xx_ll_lpuart.h stm32l4xx_ll_opamp.h stm32l4xx_ll_pka.h stm32l4xx_ll_pwr.h stm32l4xx_ll_rcc.h stm32l4xx_ll_rng.h stm32l4xx_ll_rtc.h stm32l4xx_ll_sdmmc.h stm32l4xx_ll_spi.h stm32l4xx_ll_swpmi.h stm32l4xx_ll_system.h stm32l4xx_ll_tim.h stm32l4xx_ll_usart.h stm32l4xx_ll_usb.h stm32l4xx_ll_utils.h stm32l4xx_ll_wwdg.h
    C:/Keil_v5/mbed-os/targets/TARGET_STM/TARGET_STM32L4/STM32Cube_FW/: stm32l4xx_hal_conf.h
    C:/Keil_v5/mbed-os/hal/usb/include/usb/: usb_phy_api.h USBPhy.h USBPhyEvents.h USBPhyTypes.h
  group _L476_JoyItCar_leds_sw
    ./: main.cpp
    ./: mbed_config.h
  group mbed-pre
    ./pre_build/: analogin.o analogin_api.o analogin_device.o analogout.o analogout_api.o analogout_device.o atcmdparser.o bufferedblockdevice.o bufferedserial.o busin.o businout.o busout.o can.o can_api.o chainingblockdevice.o conditionvariable.o criticalsectionlock.o cthunkbase.o deepsleeplock.o digitalin.o digitalinout.o digitalout.o eventflags.o exhaustibleblockdevice.o filebase.o filehandle.o filepath.o filesystemhandle.o flash_api.o flashiap.o flashsimblockdevice.o gpio_api.o gpio_irq_api.o gpio_irq_device.o hal_tick_overrides.o heapblockdevice.o i2c.o i2c_api.o i2c_device.o i2cslave.o interruptin.o kernel.o localfilesystem.o lowpowertickerwrapper.o lp_ticker.o mbed_alloc_wrappers.o mbed_application.o mbed_assert.o mbed_atomic_impl.o mbed_board.o mbed_compat.o mbed_crc_api.o mbed_critical.o mbed_critical_section_api.o mbed_error.o mbed_error_hist.o mbed_fault_handler.o mbed_flash_api.o mbed_gpio.o mbed_gpio_irq.o mbed_interface.o mbed_io.o mbed_itm_api.o mbed_lp_ticker_api.o mbed_lp_ticker_wrapper.o mbed_mem_trace.o mbed_mktime.o mbed_mpu_mgmt.o mbed_mpu_v7m.o mbed_mpu_v8m.o mbed_os_timer.o mbed_overrides.o mbed_pinmap_common.o mbed_pinmap_default.o mbed_poll.o mbed_power_mgmt.o mbed_printf_armlink_overrides.o mbed_printf_implementation.o mbed_printf_wrapper.o mbed_retarget.o mbed_rtc_time.o mbed_sdk_boot.o mbed_semihost_api.o mbed_stats.o mbed_thread.o mbed_ticker_api.o mbed_trace.o mbed_tz_context.o mbed_us_ticker_api.o mbed_usb_phy.o mbed_wait_api_no_rtos.o mbedcrc.o mbrblockdevice.o mstd_mutex.o mutex.o observingblockdevice.o ospi.o ospi_api.o peripheralpins.o pinmap.o port_api.o portin.o portinout.o portout.o profilingblockdevice.o pwmout.o pwmout_api.o pwmout_device.o qspi.o qspi_api.o readonlyblockdevice.o reset_reason.o resetreason.o rtc_api.o semaphore.o serial_api.o serial_device.o serialbase.o serialwireoutput.o sfdp.o sleep.o slicingblockdevice.o spi.o spi_api.o spislave.o startup_stm32l476xx.o static_pinmap.o stm_spi_api.o stm32l4xx_hal.o stm32l4xx_hal_adc.o stm32l4xx_hal_adc_ex.o stm32l4xx_hal_can.o stm32l4xx_hal_can_legacy.o stm32l4xx_hal_comp.o stm32l4xx_hal_cortex.o stm32l4xx_hal_crc.o stm32l4xx_hal_crc_ex.o stm32l4xx_hal_cryp.o stm32l4xx_hal_cryp_ex.o stm32l4xx_hal_dac.o stm32l4xx_hal_dac_ex.o stm32l4xx_hal_dcmi.o stm32l4xx_hal_dfsdm.o stm32l4xx_hal_dfsdm_ex.o stm32l4xx_hal_dma.o stm32l4xx_hal_dma_ex.o stm32l4xx_hal_dma2d.o stm32l4xx_hal_dsi.o stm32l4xx_hal_exti.o stm32l4xx_hal_firewall.o stm32l4xx_hal_flash.o stm32l4xx_hal_flash_ex.o stm32l4xx_hal_flash_ramfunc.o stm32l4xx_hal_gfxmmu.o stm32l4xx_hal_gpio.o stm32l4xx_hal_hash.o stm32l4xx_hal_hash_ex.o stm32l4xx_hal_hcd.o stm32l4xx_hal_i2c.o stm32l4xx_hal_i2c_ex.o stm32l4xx_hal_irda.o stm32l4xx_hal_iwdg.o stm32l4xx_hal_lcd.o stm32l4xx_hal_lptim.o stm32l4xx_hal_ltdc.o stm32l4xx_hal_ltdc_ex.o stm32l4xx_hal_mmc.o stm32l4xx_hal_mmc_ex.o stm32l4xx_hal_nand.o stm32l4xx_hal_nor.o stm32l4xx_hal_opamp.o stm32l4xx_hal_opamp_ex.o stm32l4xx_hal_ospi.o stm32l4xx_hal_pcd.o stm32l4xx_hal_pcd_ex.o stm32l4xx_hal_pka.o stm32l4xx_hal_pssi.o stm32l4xx_hal_pwr.o stm32l4xx_hal_pwr_ex.o stm32l4xx_hal_qspi.o stm32l4xx_hal_rcc.o stm32l4xx_hal_rcc_ex.o stm32l4xx_hal_rng.o stm32l4xx_hal_rng_ex.o stm32l4xx_hal_rtc.o stm32l4xx_hal_rtc_ex.o stm32l4xx_hal_sai.o stm32l4xx_hal_sai_ex.o stm32l4xx_hal_sd.o stm32l4xx_hal_sd_ex.o stm32l4xx_hal_smartcard.o stm32l4xx_hal_smartcard_ex.o stm32l4xx_hal_smbus.o stm32l4xx_hal_smbus_ex.o stm32l4xx_hal_spi.o stm32l4xx_hal_spi_ex.o stm32l4xx_hal_sram.o stm32l4xx_hal_swpmi.o stm32l4xx_hal_tim.o stm32l4xx_hal_tim_ex.o stm32l4xx_hal_tsc.o stm32l4xx_hal_uart.o stm32l4xx_hal_uart_ex.o stm32l4xx_hal_usart.o stm32l4xx_hal_usart_ex.o stm32l4xx_hal_wwdg.o stm32l4xx_ll_adc.o stm32l4xx_ll_comp.o stm32l4xx_ll_crc.o stm32l4xx_ll_crs.o stm32l4xx_ll_dac.o stm32l4xx_ll_dma.o stm32l4xx_ll_dma2d.o stm32l4xx_ll_exti.o stm32l4xx_ll_fmc.o stm32l4xx_ll_gpio.o stm32l4xx_ll_i2c.o stm32l4xx_ll_lptim.o stm32l4xx_ll_lpuart.o stm32l4xx_ll_opamp.o stm32l4xx_ll_pka.o stm32l4xx_ll_pwr.o stm32l4xx_ll_rcc.o stm32l4xx_ll_rng.o stm32l4xx_ll_rtc.o stm32l4xx_ll_sdmmc.o stm32l4xx_ll_spi.o stm32l4xx_ll_swpmi.o stm32l4xx_ll_tim.o stm32l4xx_ll_usart.o stm32l4xx_ll_usb.o stm32l4xx_ll_utils.o stream.o system_clock.o system_stm32l4xx.o systimer.o thisthread.o thread.o ticker.o timeout.o timer.o timerevent.o trng_api.o unbufferedserial.o us_ticker.o usbphy_stm32.o watchdog.o watchdog_api.o
  group libs
    ./: main_robot.h
